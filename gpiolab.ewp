# IAR project gpiolab.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_TM4C123_RB1
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.2.0.295
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: C:\ti\TivaWare_C_Series-2.2.0.295\driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: App.c App.h Button.c Button.h CAN.c CAN.h Common_Macros.h Compiler.h Det.c Det.h Dio.c Dio.h Dio_Cfg.h Dio_PBcfg.c Dio_Regs.h Gpt.c Gpt.h Led.c Led.h main.c Os.c Os.h Platform_Types.h Port.c Port.h Port_Cfg.h Port_PBcfg.c Port_Regs.h portf.c portf.h startup_ewarm.c Std_Types.h tm4c123gh6pm_registers.h
